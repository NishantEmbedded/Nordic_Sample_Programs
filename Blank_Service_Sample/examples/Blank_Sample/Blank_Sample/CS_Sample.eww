<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040e\s112\iar\Blank_Service_Sample_pca10040e_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\Blank_Service_Sample_pca10040_s132.ewp</path>
  </project>  <batchBuild/>
</workspace>